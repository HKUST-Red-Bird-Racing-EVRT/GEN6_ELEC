File: Schematics/VCU_connector.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: HVPDU in schematics updatedd wiring
Parts:
- J1, J2: value ~ -> (none)
